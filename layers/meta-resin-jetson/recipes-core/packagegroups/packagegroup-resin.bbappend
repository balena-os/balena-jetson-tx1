RDEPENDS_${PN} += "tegra-firmware-xusb"
