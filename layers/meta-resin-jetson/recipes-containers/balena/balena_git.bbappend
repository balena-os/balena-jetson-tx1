# FIXME: This is broken until the next upx release:
# https://github.com/upx/upx/issues/130#issuecomment-338521057
FILES_COMPRESS=""
