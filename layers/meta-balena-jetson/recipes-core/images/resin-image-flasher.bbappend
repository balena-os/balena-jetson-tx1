include resin-image.inc

RESIN_BOOT_PARTITION_FILES_append = " extlinux.conf_flasher:/extlinux/extlinux.conf"
